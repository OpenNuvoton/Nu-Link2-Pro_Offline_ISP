# Keil uVision project OFFLINE_LIB.uvproj, settings and files
target HSUSBD_Mass_Storage_Offline_ISP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: OFFLINE_LIB (library)
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\..\Library\StdDriver\inc;..\;..\ff8\src;..\HAL_Driver;..\ISP_HID_20;..\..\..\..\Library\UsbHostLib\inc;..\LUA;..\STORAGE
  asm define: Stack_Size=0x1000 Heap_Size=0x1000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c uart.c retarget.c fmc.c hsusbd.c spim.c can.c usci_i2c.c acmp.c bpwm.c crc.c crypto.c dac.c eadc.c ebi.c ecap.c emac.c epwm.c gpio.c i2c.c i2s.c pdma.c qei.c qspi.c rtc.c sc.c scuart.c sdh.c spi.c timer.c timer_pwm.c usbd.c usci_spi.c usci_uart.c wdt.c wwdt.c ccap.c trng.c
  group USB_OFFLINE
    ../ISP_OFFLINE/: isp_bridge.c ISP_CAN_BUS.C ISP_CMD.c ISP_DRIVER.C ISP_FILE_ACCESS.c ISP_I2C_BUS.C ISP_RS485_BUS.c ISP_SPI_BUS.c ISP_UART_BUS.c
  group HAL
    ../HAL_Driver/: hal_usci_i2c.c hal_timer.c hal_sys.c hal_spi.c hal_rs485.c hal_hsusbd.c hal_can_isp.c
  group USBH_MSC
    ../../../../Library/UsbHostLib/src_core/: hub.c mem_alloc.c ohci.c usb_core.c
    ../../../../Library/UsbHostLib/src_msc/: msc_driver.c msc_xfer.c
    ../../../../Library/UsbHostLib/src_hid/: hid_core.c hid_driver.c
  group FATFS
    ../ff8/src/: ff.c diskio.c
    ../ff8/src/option/: ccsbcs.c
  group STORAGE
    ../STORAGE/: SDGlue.c SPIM_SPI_FLASH.c USB_HOST_CALL.C
  group LUA
    ../LUA/: lapi.c lauxlib.c lbaselib.c lbitlib.c lcode.c lcorolib.c lctype.c ldblib.c ldebug.c ldo.c ldump.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c lparser.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltm.c lundump.c lutf8lib.c lvm.c lzio.c
  group USBD_MSC
    ../: descriptors.c MassStorage.c
